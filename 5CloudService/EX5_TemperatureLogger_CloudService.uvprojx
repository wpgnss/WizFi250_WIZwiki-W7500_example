# Keil uVision project EX5_TemperatureLogger_CloudService.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: EX5_TemperatureLogger_CloudService
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\Include;.\Libraries\CMSIS\Device\WIZnet\W7500\Include;.\Libraries\W7500x_stdPeriph_Driver\inc;..\5CloudService
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group MDK-ARM11
    ./Libraries/CMSIS/Device/WIZnet/W7500/Source/ARM/: startup_W7500x.s
  group CMSIS
    ./Libraries/CMSIS/Device/WIZnet/W7500/Source/: system_W7500x.c
  group W7500_Periphs
    ./Libraries/W7500x_stdPeriph_Driver/src/: W7500x_uart.c W7500x_gpio.c W7500x_adc.c
  group User
    ./: main.c retarget.c W7500x_it.c WizFi250Handler.c
target Target 2 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: as above
  output: EX5_TemperatureLogger_CloudService
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: CORTEX_M0 USE_STDPERIPH_DRIVER
  c include: as above
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
